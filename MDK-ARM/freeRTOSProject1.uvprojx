# Keil uVision project freeRTOSProject1.uvprojx, settings and files
target freeRTOSProject1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: freeRTOSProject1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no_multibyte_chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../freeRTOS/Inc;../Hardware;../App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group freeRTOS
    ../freeRTOS/Src/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
  group App
    ../App/: AcquisitionTask.c AcquisitionTask.h displayTask.c displayTask.h AppResources.h AppResources.c SensorData.c SensorData.h StorageTask.c StorageTask.h ModbusTask.c ModbusTask.h
  group Hardware
    ../Hardware/: AnalogInput.c AnalogInput.h ConfigStore.c ConfigStore.h DataLogger.c DataLogger.h DeviceConfig.c DeviceConfig.h FlashLayout.c FlashLayout.h ModbusCRC.c ModbusCRC.h ModbusRegisters.c ModbusRegisters.h ModbusSlave.c ModbusSlave.h OLED.c OLED.h OLED_Font.h RingBuffer.c RingBuffer.h SHT30.c SHT30.h TempAlarm.c TempAlarm.h W25Q32.c W25Q32.h
software components: CMSIS:CORE 4.3.0
